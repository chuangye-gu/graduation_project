# Keil uVision project LWl-F103.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LWl-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libaraies\CMSIS;..\Libaraies\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\bsp-lcd1602;..\User\SysTick;..\User\led;..\User\24c02;..\User\max6675;..\User\PID;..\User\pidout;..\User\timer_init;..\User\display;..\User\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libaraies/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libaraies/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libaraies/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/bsp-lcd1602/: bsp-lcd1602.c
    ../User/SysTick/: bsp_SysTick.c
  group DOC
    ../Doc/: Readme.txt
  group led
    ../User/led/: led.c
  group 24C02
    ../User/24c02/: 24c02.c
  group max6675
    ../User/max6675/: max6675.c
  group pid
    ../User/PID/: PID.C
  group pidout
    ../User/pidout/: pidout.c
  group timer
    ../User/timer_init/: timer_init.c
  group display
    ../User/display/: display.c
  group usart
    ../User/usart/: usart.c
